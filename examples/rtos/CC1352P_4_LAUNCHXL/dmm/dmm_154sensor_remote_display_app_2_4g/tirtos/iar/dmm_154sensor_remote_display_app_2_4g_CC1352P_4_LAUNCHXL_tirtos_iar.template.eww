<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/dmm_154sensor_remote_display_app_2_4g_CC1352P_4_LAUNCHXL_tirtos_iar.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>dmm_154sensor_remote_display_app_2_4g</name>
      <member>
        <project>dmm_154sensor_remote_display_app_2_4g_CC1352P_4_LAUNCHXL_tirtos_iar</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
