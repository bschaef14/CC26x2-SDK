# IAR project simple_broadcaster_CC13X2P_4_LAUNCHXL_tirtos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group (top)
    ./: simple_broadcaster_CC13X2P_4_LAUNCHXL_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf simple_broadcaster_app.cfg
