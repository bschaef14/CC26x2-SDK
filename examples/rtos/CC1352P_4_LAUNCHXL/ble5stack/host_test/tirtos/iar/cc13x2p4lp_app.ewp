# IAR project cc13x2p4lp_app.ewp, settings and files
configuration FlashROM_Release (ARM, debug)
  General.OGChipSelectEditMenu: CC1352P1F3 TexasInstruments CC1352P1F3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC13X2; FLASH_ROM_BUILD; NVOCMP_NWSAMEITEM=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; -f $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\config\build_components.opt; -f $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\config\factory_config.opt; -f $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\examples\rtos\CC1352P_4_LAUNCHXL\ble5stack\host_test\tirtos\build_config.opt; -f config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\controller\cc26xx\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\rom; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\common\cc26xx; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\common\cc26xx\rcosc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\examples\rtos\CC1352P_4_LAUNCHXL\ble5stack\host_test\src\app; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\icall\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target\_common; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target\_common\cc26xx; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\heapmgr; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\icall\src\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\npi\src; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\osal\src\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\services\src\saddr; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\services\src\sdata; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\common\cc26xx; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\common\nv; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; ..\..\; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o config\configPkg $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\examples\rtos\CC1352P_4_LAUNCHXL\ble5stack\host_test\tirtos\ble_release.cfg
  ILINK.IlinkOutputFile: ble5_host_test_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2642=1; FLASH_ROM_BUILD=2; PAGE_ALIGN=1
  ILINK.IlinkIcfFile: $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\common\cc26xx\iar\cc26xx_app_and_stack_agama.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f config\configPkg\linker.cmd; -L $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source; -L $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\kernel\tirtos\packages; -f ..\..\src\app\ti_utils_build_linker.cmd.genlibs; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\libraries\cc1352p\ble_r2.symbols; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\libraries\cc1352p\OneLib.a; $OUT_DIR$\StackWrapper.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_Debug (ARM, debug)
  as the first configuration, except:
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o config\configPkg $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\examples\rtos\CC1352P_4_LAUNCHXL\ble5stack\host_test\tirtos\ble_debug.cfg
  group (top)
    ../../src/app/: host_test.syscfg
  group Application
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/examples/rtos/CC1352P_4_LAUNCHXL/ble5stack/host_test/src/app/: host_test_app.c host_test_app.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/: util.c util.h
  group Drivers/NV
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/common/nv/: crc.c crc.h nvocmp.c nvocmp.h
  group ICall
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/src/inc/: icall.h icall_user_config.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/inc/: icall_addrs.h
  group ICallBLE
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/app/: ble_user_config.c icall_api_lite.c icall_hci_tl.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/inc/: ble_user_config.h icall_ble_apimsg.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/stack/: ble_user_config_stack.c
  group NPI
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/inc/: npi_ble.h npi_frame.h npi_rxbuf.h npi_task.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/: npi_frame_hci.c npi_rxbuf.c npi_task.c
  group NPI/Transport
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/inc/: npi_config.h npi_tl.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/: npi_tl.c
  group NPI/Transport/SPI
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/: npi_tl_spi.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/inc/: npi_tl_spi.h
  group NPI/Transport/UART
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/: npi_tl_uart.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/inc/: npi_tl_uart.h
  group Startup
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/examples/rtos/CC1352P_4_LAUNCHXL/ble5stack/host_test/src/: ccfg_app_ble.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/rcosc/: ccfg_app_ble_rcosc_agama.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/examples/rtos/CC1352P_4_LAUNCHXL/ble5stack/host_test/src/app/: osal_icall_ble.c main.c
  group Tools
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/rom/agama_r1/: rom_init.c
    ../: ble_debug.cfg ble_release.cfg
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/examples/rtos/CC1352P_4_LAUNCHXL/ble5stack/host_test/tirtos/: build_config.opt
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/iar/: cc26xx_app_and_stack_agama.icf
  group Tools/defines
    defines/: cc13x2p4lp_app_FlashROM_Debug.opt cc13x2p4lp_app_FlashROM_Release.opt
