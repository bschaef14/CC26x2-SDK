<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\cc13x2p4lp_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\StackWrapper\tirtos\iar\stack_wrapper.ewp</path>
  </project>
  <batchBuild/>
</workspace>


