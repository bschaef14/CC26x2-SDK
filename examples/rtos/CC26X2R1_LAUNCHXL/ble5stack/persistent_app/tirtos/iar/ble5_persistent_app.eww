<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\persistent_app\cc26x2r1lp_persistent_app.ewp</path>
  </project>
  <batchBuild/>
</workspace>


