# IAR project coprocessor_CC26X2R1_LAUNCHXL_tirtos_iar.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  group (top)
    ./: coprocessor_CC26X2R1_LAUNCHXL_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf app_cop.cfg
