<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/aesKeyAgreement_CC2652RB_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/kernel/tirtos/builds/cc13x2_cc26x2/release/iar/tirtos_builds_cc13x2_cc26x2_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>