<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/empty_mtd_CC2652RB_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC2652RB_LAUNCHXL/thread/libopenthread_mtd/tirtos/iar/libopenthread_mtd_CC2652RB_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC2652RB_LAUNCHXL/thread/libopenthread_platform_utils_mtd/tirtos/iar/libopenthread_platform_utils_mtd_CC2652RB_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC2652RB_LAUNCHXL/thread/libmbedcrypto/tirtos/iar/libmbedcrypto_CC2652RB_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>empty_mtd</name>
            <member>
                <project>libopenthread_mtd_CC2652RB_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libopenthread_platform_utils_mtd_CC2652RB_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libmbedcrypto_CC2652RB_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>empty_mtd_CC2652RB_LAUNCHXL_tirtos_iar</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>