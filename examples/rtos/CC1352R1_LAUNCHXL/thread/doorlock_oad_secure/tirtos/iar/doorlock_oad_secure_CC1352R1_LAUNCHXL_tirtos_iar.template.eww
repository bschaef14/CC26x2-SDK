<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/doorlock_oad_secure_CC1352R1_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC1352R1_LAUNCHXL/thread/libopenthread_mtd/tirtos/iar/libopenthread_mtd_CC1352R1_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC1352R1_LAUNCHXL/thread/libopenthread_platform_utils_mtd/tirtos/iar/libopenthread_platform_utils_mtd_CC1352R1_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC1352R1_LAUNCHXL/thread/libmbedcrypto/tirtos/iar/libmbedcrypto_CC1352R1_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>doorlock_oad_secure</name>
            <member>
                <project>libopenthread_mtd_CC1352R1_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libopenthread_platform_utils_mtd_CC1352R1_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libmbedcrypto_CC1352R1_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>doorlock_oad_secure_CC1352R1_LAUNCHXL_tirtos_iar</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>