# IAR project stack_wrapper.ewp, settings and files
configuration Stack_Wrapper (ARM, debug)
  General.OGChipSelectEditMenu: CC1352R1F3 TexasInstruments CC1352R1F3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -f ..\..\Stack_Wrapper.opt; --aeabi; -f $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\config\build_components.opt; -f $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\config\factory_config.opt; -f $BUILD_CONFIG_DIR$\build_config.opt; --diag_suppress=Pa050; -Dxdc_target_types__=iar\targets\arm\std.h; --make_all_definitions_weak
  ICCARM.CCIncludePath2: $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\controller\cc26xx\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\rom; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\common\cc26xx; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\common\cc26xx\npi\stack; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target\_common; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\icall\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target\_common\cc26xx; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target\_common; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\icall\src\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\npi\src; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\osal\src\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\common\nv; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\ble5stack\services\src\saddr; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\rf_patches; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\cc13x2_cc26x2\inc; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source; $XDCROOT$\packages
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  ILINK.IlinkOutputFile: stack_wrapper.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=2; CC2650=2
  ILINK.IlinkProgramEntryLabel: startup_entry
  group HAL/API
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/: crypto_api.h ecc_api.h rf_api.h rtos_drivers.h trng_api.h
  group HAL/Common
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/common/: hal_assert.c
  group HAL/Include
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/: hal_mcu.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/cc26xx/: mb.h rf_hal.h
  group HAL/Target/CC2650/Config
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group Host
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/host/: gap.c gapbondmgr.c gatt_uuid.c gattservapp_util.c sm_ecc.c rtls_srv.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/inc/: gapbondmgr.h gapgattserver.h gatt_uuid.h gattservapp.h rtls_srv_api.h
  group ICallBLE
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/inc/: ble_dispatch.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/stack/: ble_dispatch_JT.c ble_dispatch_lite.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/src/: icall_lite_translation.c
  group NPI
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/npi/stack/: npi.c
  group OSAL
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_list.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_list.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group ROM
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/rom/agama_r1/: common_rom_init.c rom_flash_jt.h
  group Startup
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/: icall_startup.c
  group Tools
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/config/: build_components.opt
    $BUILD_CONFIG_DIR$/: build_config.opt
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/: onboard.c onboard.h
  group Tools/defines
    ../../: Stack_Wrapper.opt
