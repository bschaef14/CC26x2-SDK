# IAR project cc13x2r1lp_persistent_app.ewp, settings and files
configuration FlashROM_Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1352R1F3 TexasInstruments CC1352R1F3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC13X2; FLASH_ROM_BUILD; NVOCMP_NWSAMEITEM=1; OAD_ONCHIP; SECURITY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\persistent_app\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_COMMON_DIR$\..; $SRC_COMMON_DIR$\cc26xx\flash_interface; $SRC_COMMON_DIR$\cc26xx\crc; $SRC_COMMON_DIR$\cc26xx\bim; $EXAMPLE_BLE_ROOT$\src\persistent_app; $EXAMPLE_BLE_ROOT$\src; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\profiles\simple_profile\cc26xx; $SRC_BLE_DIR$\profiles\oad\cc26xx; $SRC_COMMON_DIR$\cc26xx\oad; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SRC_BLE_DIR$\..\common\cc26xx; $SRC_BLE_DIR$\..\common\nv; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sp_oad_onchip_$PROJ_FNAME$_$CONFIG_NAME$.hex
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs "{OAD_IMG_A:1}" -o "..\config\persistent_app\configPkg" $EXAMPLE_BLE_ROOT$\tirtos\ble_debug.cfg"
  ILINK.IlinkOutputFile: sp_oad_onchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2642=1; FLASH_ROM_BUILD=2; PAGE_ALIGN=1; OAD_IMG_A=1
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_and_stack_agama_oad_onchip.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\persistent_app\configPkg\linker.cmd; -L $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source; -L $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\kernel\tirtos\packages; -f ..\..\..\src\ti_utils_build_linker.cmd.genlibs; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkAdditionalLibs: $SRC_BLE_DIR$\libraries\cc13x2r1\ble_r2.symbols; $SRC_BLE_DIR$\libraries\cc13x2r1\OneLib.a; $SRC_BLE_DIR$\libraries\cc13x2r1\StackWrapper.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DeviceFamily_CC13X2; FLASH_ROM_BUILD; NVOCMP_NWSAMEITEM=1; LED_DEBUG
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_COMMON_DIR$\..; $SRC_COMMON_DIR$\cc26xx\flash_interface; $SRC_COMMON_DIR$\cc26xx\crc; $SRC_COMMON_DIR$\cc26xx\bim; $EXAMPLE_BLE_ROOT$\src\persistent_app; $EXAMPLE_BLE_ROOT$\src; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\profiles\simple_profile\cc26xx; $SRC_BLE_DIR$\profiles\oad\cc26xx; $SRC_COMMON_DIR$\cc26xx\oad; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SRC_BLE_DIR$\..\common\cc26xx; $SRC_BLE_DIR$\..\common\nv; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$\source
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs "{OAD_IMG_A:1}" -o "..\config\persistent_app\configPkg" $EXAMPLE_BLE_ROOT$\tirtos\ble_release.cfg"
  group (top)
    $EXAMPLE_BLE_ROOT$/src/: persistent_app.syscfg
  group Application
    $EXAMPLE_BLE_ROOT$/src/: oad_persistent_app.c oad_persistent_app.h
    $SRC_BLE_DIR$/common/cc26xx/: util.c util.h
  group Drivers/ECC
    $SRC_BLE_DIR$/../common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/NV
    $SRC_BLE_DIR$/../common/nv/: crc.c crc.h nvocmp.c nvocmp.h
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/drivers/: NVS.c
    $SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/drivers/nvs/: NVSCC26XX.c NVSRAM.c
  group ICall
    $SRC_BLE_DIR$/heapmgr/: heapmgr.h
    $SRC_BLE_DIR$/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SRC_BLE_DIR$/icall/src/inc/: icall.h
    $SRC_BLE_DIR$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_DIR$/icall/app/: ble_user_config.c icall_api_lite.c
    $SRC_BLE_DIR$/icall/inc/: ble_user_config.h icall_ble_apimsg.h
    $SRC_BLE_DIR$/icall/stack/: ble_user_config_stack.c
  group Include
    $SRC_BLE_DIR$/inc/: gap.h gapbondmgr.h gapgattserver.h gatt.h hci.h
    $SRC_BLE_DIR$/osal/src/inc/: osal_snv.h
  group OAD
    $SRC_COMMON_DIR$/cc26xx/crc/: crc32.c crc32.h
    $SRC_COMMON_DIR$/cc26xx/flash_interface/: flash_interface.h
    $SRC_COMMON_DIR$/cc26xx/flash_interface/internal/: flash_interface_int_rtos_NVS.c
    $SRC_BLE_DIR$/profiles/oad/cc26xx/: oad.c oad.h oad_defines.h oad_image_header_app.c
    $SRC_COMMON_DIR$/cc26xx/oad/: oad_image_header.h
  group Profiles
    $SRC_BLE_DIR$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_BLE_DIR$/profiles/dev_info/: devinfoservice.h
    $SRC_BLE_DIR$/inc/: gatt_profile_uuid.h gatt_uuid.h
    $SRC_BLE_DIR$/host/: gatt_uuid.c gattservapp_util.c
  group Startup
    $EXAMPLE_BLE_ROOT$/src/: osal_icall_ble.c main.c
    $SRC_BLE_DIR$/rom/agama_r1/: rom_init.c
  group Tools
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_app_and_stack_agama_oad_onchip.icf
  group Tools/defines
    ../../: ble_debug.cfg ble_release.cfg
    defines/: cc13x2r1lp_persistent_app_FlashROM_Debug.opt cc13x2r1lp_persistent_app_FlashROM_Release.opt
