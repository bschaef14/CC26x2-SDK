# IAR project benchloop_LP_CC2652RSIP_tirtos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: benchloop_LP_CC2652RSIP_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf benchloop.cfg
