<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/ncp_ftd_LP_CC2652RSIP_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/LP_CC2652RSIP/thread/libopenthread_ncp_ncp/tirtos/iar/libopenthread_ncp_ncp_LP_CC2652RSIP_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/LP_CC2652RSIP/thread/libopenthread_ncp/tirtos/iar/libopenthread_ncp_LP_CC2652RSIP_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/LP_CC2652RSIP/thread/libopenthread_platform_utils_ncp/tirtos/iar/libopenthread_platform_utils_ncp_LP_CC2652RSIP_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/LP_CC2652RSIP/thread/libmbedcrypto/tirtos/iar/libmbedcrypto_LP_CC2652RSIP_tirtos_iar.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ncp_ftd</name>
            <member>
                <project>libopenthread_ncp_ncp_LP_CC2652RSIP_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libopenthread_ncp_LP_CC2652RSIP_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libopenthread_platform_utils_ncp_LP_CC2652RSIP_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libmbedcrypto_LP_CC2652RSIP_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>ncp_ftd_LP_CC2652RSIP_tirtos_iar</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>