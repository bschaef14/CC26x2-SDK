<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/cli_mtd_CC1352P_2_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC1352P_2_LAUNCHXL/thread/libopenthread_cli_mtd/tirtos/iar/libopenthread_cli_mtd_CC1352P_2_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC1352P_2_LAUNCHXL/thread/libopenthread_mtd/tirtos/iar/libopenthread_mtd_CC1352P_2_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC1352P_2_LAUNCHXL/thread/libopenthread_platform_utils_mtd/tirtos/iar/libopenthread_platform_utils_mtd_CC1352P_2_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/thread/rtos/CC1352P_2_LAUNCHXL/thread/libmbedcrypto/tirtos/iar/libmbedcrypto_CC1352P_2_LAUNCHXL_tirtos_iar.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>cli_mtd</name>
            <member>
                <project>libopenthread_cli_mtd_CC1352P_2_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libopenthread_mtd_CC1352P_2_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libopenthread_platform_utils_mtd_CC1352P_2_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>libmbedcrypto_CC1352P_2_LAUNCHXL_tirtos_iar</project>
                <configuration>OptimizeSize</configuration>
            </member>
            <member>
                <project>cli_mtd_CC1352P_2_LAUNCHXL_tirtos_iar</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>