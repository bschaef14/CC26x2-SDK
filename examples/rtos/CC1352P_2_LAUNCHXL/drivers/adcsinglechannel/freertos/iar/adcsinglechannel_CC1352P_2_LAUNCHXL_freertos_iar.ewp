# IAR project adcsinglechannel_CC1352P_2_LAUNCHXL_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: adcsinglechannel_CC1352P_2_LAUNCHXL_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
