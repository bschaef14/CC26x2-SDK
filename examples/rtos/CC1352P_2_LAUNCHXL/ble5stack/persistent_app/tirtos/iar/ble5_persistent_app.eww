<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\persistent_app\cc13x2p2lp_persistent_app.ewp</path>
  </project>
  <batchBuild/>
</workspace>


