# IAR project dmm_wsnnode_ble_sp_oad_app_CC1352P_2_LAUNCHXL_tirtos_iar.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  group (top)
    ./: dmm_wsnnode_ble_sp_oad_app_CC1352P_2_LAUNCHXL_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf ble_oad_release.cfg
