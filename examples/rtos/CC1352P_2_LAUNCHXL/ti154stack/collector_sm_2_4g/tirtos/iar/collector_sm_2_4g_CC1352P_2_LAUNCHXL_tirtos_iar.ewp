# IAR project collector_sm_2_4g_CC1352P_2_LAUNCHXL_tirtos_iar.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  group (top)
    ./: collector_sm_2_4g_CC1352P_2_LAUNCHXL_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf app.cfg
