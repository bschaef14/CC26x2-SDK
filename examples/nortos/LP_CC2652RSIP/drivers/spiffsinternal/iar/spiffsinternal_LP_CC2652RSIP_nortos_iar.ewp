# IAR project spiffsinternal_LP_CC2652RSIP_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: spiffsinternal_LP_CC2652RSIP_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
