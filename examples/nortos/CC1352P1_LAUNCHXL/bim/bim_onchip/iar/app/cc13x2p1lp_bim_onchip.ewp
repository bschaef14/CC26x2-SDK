# IAR project cc13x2p1lp_bim_onchip.ewp, settings and files
configuration Debug_unsecure (ARM, debug)
  General.OGChipSelectEditMenu: CC1352P1F3 TexasInstruments CC1352P1F3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC13X2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt
  ICCARM.CCIncludePath2: $SRC_COMMON_DIR$; $SIMPLELINK_CORE_SDK_INSTALL_DIR$; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cc13x2p1lp_bim_onchip.hex
  ILINK.IlinkOutputFile: sp_oad_onchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2642=1; xPAGE_ALIGN=1
  ILINK.IlinkIcfFile: $SRC_COMMON_DIR$\cc26xx\iar\bim_cc26x2_cc13x2.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_unsecure (ARM, debug)
  as the first configuration, except:
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $SRC_COMMON_DIR$; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $SRC_COMMON_DIR$\cc26xx\flash_interface; $SRC_COMMON_DIR$\cc26xx\sha2; $SRC_COMMON_DIR$\cc26xx\ecc; $SRC_COMMON_DIR$\cc26xx\oad; $SRC_COMMON_DIR$\cc26xx\crc; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_COMMON_DIR$\flash\no_rtos\extFlash
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\driverlib\bin\iar\driverlib.lib; $SRC_BLE_DIR$\rom\ble_rom_releases\cc26x2_v2_pg2\Final_Release\ble_rom.symbols
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: as above
  group Application
    ../../src/: bim_main.c ccfg_app.c
    $SRC_COMMON_DIR$/cc26xx/bim/: bim_util.c bim_util.h
    $SRC_COMMON_DIR$/cc26xx/crc/: crc32.c crc32.h
    $SRC_COMMON_DIR$/cc26xx/flash_interface/: flash_interface.h
    $SRC_COMMON_DIR$/cc26xx/flash_interface/internal/: flash_interface_internal.c
    $SRC_COMMON_DIR$/cc26xx/debug/: led_debug.c led_debug.h
    $SRC_COMMON_DIR$/cc26xx/oad/: oad_image_header.h
    $SRC_COMMON_DIR$/cc26xx/ecc/: sign_util.c sign_util.h
    $SRC_COMMON_DIR$/cc26xx/sha2/: sha2_driverlib.c sha2_driverlib.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/startup_files/: startup_iar.c
  group Board
    $SRC_COMMON_DIR$/flash/no_rtos/extFlash/: bsp.h
  group Tools
    $SRC_COMMON_DIR$/cc26xx/iar/: bim_cc26x2_cc13x2.icf
  group Tools/defines
    defines/: cc13x2p1lp_bim_onchip_Debug.opt cc13x2p1lp_bim_onchip_Debug_unsecure.opt cc13x2p1lp_bim_onchip_Release.opt cc13x2p1lp_bim_onchip_Release_unsecure.opt
