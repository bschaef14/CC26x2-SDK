<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app\cc13x2p1lp_bim_offchip.ewp</path>
  </project>
  <batchBuild/>
</workspace>


