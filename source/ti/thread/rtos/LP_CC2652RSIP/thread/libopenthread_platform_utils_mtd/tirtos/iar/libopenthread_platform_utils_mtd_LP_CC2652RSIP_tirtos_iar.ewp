# IAR project libopenthread_platform_utils_mtd_LP_CC2652RSIP_tirtos_iar.ewp, settings and files
configuration OptimizeSize (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: libopenthread_platform_utils_mtd_LP_CC2652RSIP_tirtos_iar.ipcf
